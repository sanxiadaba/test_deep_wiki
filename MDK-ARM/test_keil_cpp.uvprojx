# Keil uVision project test_keil_cpp.uvprojx, settings and files
target test_keil_cpp (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: test_keil_cpp +hex
  c flags: Optim=5 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=4 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../z_util;../third_party/segger_rtt;../bsp;../third_party/MultiTimer;../device/device_led;../device/device_key;../device/device_iic;../device/device_at24c02;../device/device_spi;..\device\device_w25q64
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c iwdg.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group z_util
    ../z_util/: z_callback.cpp z_debug.cpp z_define.cpp z_filter.cpp z_include.cpp z_init.cpp z_math.cpp z_port.cpp z_printf.cpp z_ringbuffer.cpp z_sort.cpp z_test.cpp z_util.cpp z_while.cpp
  group third_party
    ../third_party/MultiTimer/: MultiTimer.cpp
    ../third_party/segger_rtt/: SEGGER_RTT.cpp SEGGER_RTT_printf.cpp
  group bsp
    ../bsp/: bsp_define.cpp bsp_delay.cpp bsp_flash.cpp bsp_gpio.cpp bsp_include.cpp bsp_init.cpp bsp_port.cpp bsp_task.cpp bsp_task_callback.cpp
  group device
    ../device/device_led/: device_led.cpp
    ../device/device_key/: device_key.cpp
    ../device/device_iic/: device_iic.cpp
    ../device/device_at24c02/: device_at24c02.cpp
    ../device/device_spi/: device_spi.cpp
    ../device/device_w25q64/: device_w25q64.cpp
software components: CMSIS:CORE 5.5.0
